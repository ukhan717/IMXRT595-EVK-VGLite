# Keil uVision project Project.uvprojx, settings and files
target IMXRT595-EVK-VGLite (6180000::V6.18::ARMCLANG)
  device: MIMXRT595SFFOC:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.15.1.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: EmbeddedWizard-IMXRT595-EVK-VGLite.elf
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MCUXPRESSO, __USE_CMSIS, NDEBUG, CPU_MIMXRT595SFFOC_cm33, BOOT_HEADER_ENABLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, BOARD_ENABLE_PSRAM_CACHE=0, SSD1963_DATA_WITDH=8, FLEXIO_MCULCD_DATA_BUS_WIDTH=8 , CUSTOM_VGLITE_MEMORY_CONFIG=0, SDK_OS_FREE_RTOS, SERIAL_PORT_TYPE_UART=1, SDK_I2C_BASED_COMPONENT_USED=1, VG_BLIT_WORKAROUND=1, EW_USE_VGLITE_INDEX8=1, EW_USE_OPERATING_SYSTEM=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../Source;../../../ThirdParty/MCUXpressoSDK/CMSIS/Core/Include;../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos_kernel/include;../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S;../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/drivers;../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities;../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities/debug_console;../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities/str;../../../ThirdParty/MCUXpressoSDK/components/serial_manager;../../../ThirdParty/MCUXpressoSDK/components/ssd1963;../../../ThirdParty/MCUXpressoSDK/components/video;../../../ThirdParty/MCUXpressoSDK/components/video/display;../../../ThirdParty/MCUXpressoSDK/components/video/display/fbdev;../../../ThirdParty/MCUXpressoSDK/components/video/display/mipi_dsi_cmd;../../../ThirdParty/MCUXpressoSDK/components/video/display/rm68191;../../../ThirdParty/MCUXpressoSDK/components/video/display/rm68200;../../../ThirdParty/MCUXpressoSDK/components/video/display/rm67162;../../../ThirdParty/MCUXpressoSDK/components/video/display/dc/dsi_cmd;../../../ThirdParty/MCUXpressoSDK/components/video/display/dbi;../../../ThirdParty/MCUXpressoSDK/components/video/display/dbi/flexio;../../../ThirdParty/MCUXpressoSDK/components/video/display/dc/ssd1963;../../../ThirdParty/MCUXpressoSDK/components/video/display/dc/lcdif;../../../ThirdParty/MCUXpressoSDK/components/ft3267;../../../ThirdParty/MCUXpressoSDK/components/gt911;../../../ThirdParty/MCUXpressoSDK/components/ft5406;../../../ThirdParty/MCUXpressoSDK/components/uart;../../../ThirdParty/MCUXpressoSDK/components/video/display/dc;../../../ThirdParty/MCUXpressoSDK/middleware/vglite/inc;../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLiteKernel;../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLiteKernel/rtos;../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLite/rtos;../../../PlatformPackage/RTE;../../../TargetSpecific;../../../TargetSpecific/Drivers;../../GeneratedCode
  asm define: DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x20000
  memory RVCT2: ROM 0x20000000 size 0x20000
  memory RVCT3: ROM 0x30000000 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x10300000 size 0x200000
  memory RVCT7: RAM 0x20300000 size 0x200000
  memory RVCT8: RAM 0x30300000 size 0x200000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x300000 size 0x200000
  scatter file: .\MIMXRT595Sxxxx_cm33_flash.scf
  link misc: --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x800"
  group board
    ../../../TargetSpecific/Drivers/: display_support.c pin_mux.c board.c clock_config.c vglite_support.c flash_config.c
  group drivers
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/drivers/: fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_dma.c fsl_dma.h fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_flexio_mculcd_smartdma.c fsl_flexio_mculcd_smartdma.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_lcdif.h fsl_lcdif.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_i2c.h fsl_i2c.c fsl_mipi_dsi_smartdma.c fsl_mipi_dsi_smartdma.h fsl_power.h fsl_power.c fsl_flexspi.c fsl_flexspi.h fsl_cache.c fsl_cache.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_reset.h fsl_reset.c fsl_smartdma.h fsl_smartdma.c fsl_smartdma_prv.h fsl_inputmux_connections.h fsl_soc_mipi_dsi.h fsl_iap.h fsl_iap.c fsl_rtc.c
  group device
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group startup
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/arm/: startup_MIMXRT595S_cm33.S
  group EmWi/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_os.c ew_bsp_system.c ew_bsp_touch.c
  group EmWi/Application
    ../../Source/: DeviceDriver.c ewconfig.h ewmain.c FreeRTOSConfig.h main.c
  group FreeRTOS
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos_kernel/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group vglite
    ../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
    ../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLite/rtos/: vg_lite_os.c
    ../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c
    ../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLiteKernel/: vg_lite_kernel.c
  group components
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/rm67162/: fsl_rm67162.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/: fsl_video_common.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/dbi/flexio/: fsl_dbi_flexio_smartdma.c
    ../../../ThirdParty/MCUXpressoSDK/components/ft3267/: fsl_ft3267.c
    ../../../ThirdParty/MCUXpressoSDK/components/uart/: fsl_adapter_usart.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/fbdev/: fsl_fbdev.c
    ../../../ThirdParty/MCUXpressoSDK/components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_port_uart.c
  group utilities
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities/str/: fsl_str.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities/: fsl_assert.c
software components: Graphics:Embedded Wizard:New Project... 1.0.0
